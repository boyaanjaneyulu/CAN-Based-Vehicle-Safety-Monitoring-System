# Keil uVision project CAN_Veh_Monitoring_Safety_MAIN_NODE.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: CAN_Veh_Monitoring_Safety_MIAN_NODE +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s Major_main.c CAN.c DS18B20.c LCD_functions.c delay_functions.c EINT.c project_functions.c
