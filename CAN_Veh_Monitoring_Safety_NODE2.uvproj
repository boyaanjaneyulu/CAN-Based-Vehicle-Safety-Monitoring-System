# Keil uVision project CAN_Veh_Monitoring_Safety_NODE2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: CAN_Veh_Monitoring_Safety_NODE2 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s CAN.c delay_functions.c MAIN_NODE2.c ultrasonic.c
